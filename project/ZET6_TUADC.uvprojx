# Keil uVision project ZET6_TUADC.uvprojx, settings and files
target ZET6_TUADC (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ZET6_DEMO +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\user;..\cmsis;..\Fwlib\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ../user/: main.c sys.c delay.c bsp_adc.c ds18b20.c bsp_usart1.c
  group CMSIS
    ../cmsis/: core_cm3.c stm32f10x_it.c system_stm32f10x.c startup_stm32f10x_hd.s stm32f10x_conf.h
  group FWLIB
    ../Fwlib/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_dma.c
